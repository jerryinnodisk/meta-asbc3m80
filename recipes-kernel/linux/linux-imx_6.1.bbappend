FILESEXTRAPATHS:prepend := "${THISDIR}/linux-imx:"

SRC_URI += " \
	     file://0001-modified-arch-arm64-boot-dts-Makefile.patch"
